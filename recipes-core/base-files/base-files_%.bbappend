# Modifie la recette base-files d'OpenEmbedded-Core sans la toucher :
# nom d'hote de la passerelle, au lieu du nom de la machine (qemux86-64).
hostname = "iot-gateway"
